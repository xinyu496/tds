# Keil uVision project General.uvprojx, settings and files
target general_F1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: General
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\algorithm;..\cmsis;..\hardware;..\lib\src;..\lib\inc;..\readtxt;..\rtos;..\startup;..\user;..\rtos\include;..\rtos\port\RVDS\ARM_CM3;..\rtos\port\MemMang;..\rtos\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f10x_cl.s
  group USER
    ./: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h cpu.c FreeRTOSConfig.h include.h
  group CMSIS
    ../cmsis/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group LIBRARY
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../hardware/: tim.c rtc.c uart.c gpio.c adc.c dac.c iic.c spi.c
  group RTOS
    ../rtos/port/MemMang/: heap_4.c
    ../rtos/port/RVDS/ARM_CM3/: port.c
    ../rtos/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
